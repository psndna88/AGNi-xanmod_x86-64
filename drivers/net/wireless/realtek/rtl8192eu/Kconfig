## drivers/net/wireless/realtek/rtl8192eu/Kconfig
```kconfig
config RTL8192EU_OEM
	tristate "Realtek 8192E USB WiFi by Realtek"
	depends on USB
```
